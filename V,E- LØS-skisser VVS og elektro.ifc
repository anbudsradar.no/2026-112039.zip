Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 09b435a4-238e-4afc-93e5-907784946dbb, VersionGUID: 509d3419-0239-442d-bf77-5005b9297756, NumberOfSaves: 63], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: LØS-skisser VVS og elektro.ifc
Time: 2026-06-22T07:50:16+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.30.30 (ENU) - IFC 25.4.30.30

# IfcProject, 2024129
LongName: Lærdalsøyri skule; Phase: ---

# IfcSite, Default
RefLatitude: 59, 54, 44, 239196; RefLongitude: 10, 45, 0, 0; RefElevation: 0 mm

# IfcSite: Modellnullpunkt:Site objekt, Modellnullpunkt:Site objekt:3281995
Material: Default(2), Default(1), Default, Default(3)
Pset_DrainageReserve - Width: 61.5385 mm

# IfcBuilding, Bygning (endres i Project Information)
LongName: Bygning (endres i Project Information)
Pset_BuildingCommon - NumberOfStoreys: 3

# IfcBuildingStorey: Level:NO_Nivå_Meter-VVS (3)
In: Bygning (endres i Project Information)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName | Elevation (mm) | Name
01 | Plan 01 | 0 | Plan 01
1. etasje | 1. etasje | 3820 | 1. etasje
2. etasje | 1. 2. Etasje | 7320 | 2. etasje

# IfcBuildingElementProxy: Envistar Flex, 400:Envistar Flex, 400, Envistar Flex, 400:Envistar Flex, 400:5378358
In: 2. etasje
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: IV Produkt AB
Pset_BuildingElementProxyCommon - Reference: Envistar Flex, 400; sets with these values: 2
Pset_ProductRequirements - Name: AHU Envistar Flex, 400
Group: 3601.001.04 Tilluft: 5; 3601.001.01 Inntak: 1; 3601.001.05 Avtrekk: 7; 3601.001.02 Avkast: 1

# IfcBuildingElementProxy: Envistar Top, 10:Envistar Top, 10, Envistar Top, 10:Envistar Top, 10:5424478
In: 2. etasje
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: IV Produkt AB
Pset_BuildingElementProxyCommon - Reference: Envistar Top, 10; sets with these values: 2
Pset_ProductRequirements - Name: AHU Envistar Top, 10
Group: 3601.001.04 Tilluft: 13; 3601.001.01 Inntak: 3; 3601.001.05 Avtrekk: 13; 3601.001.02 Avkast: 5

# IfcCovering: Duct Insulation:GLAVA kondensisol. rull 25mm (10)
In: 1. etasje
Type - PredefinedType: INSULATION
Pset_CoveringCommon - Reference: GLAVA kondensisol. rull 25mm; sets with these values: 2
Name (Duct Insulation:GLAVA kondensisol. rull 25mm:...) | Material
5435773 | 3601.001 Inntak
5435774 | 3601.001 Inntak
5435828 | 3601.001 Avkast
5435829 | 3601.001 Avkast
5435830 | 3601.001 Avkast
5437517 | 3601.001 Inntak
5437565 | 3601.001 Inntak
5437571 | 3601.001 Inntak
5437725 | 3601.001 Inntak
5437730 | 3601.001 Inntak

# IfcDistributionPort (628)
Description: Flow
Name | FlowDirection | Group
InPort_5381217_0 | SINK | 3601.001.04 Tilluft: 5
OutPort_5378358_1 | SOURCE | 3601.001.04 Tilluft: 5
InPort_5378358_2 | SINK | 3601.001.01 Inntak: 1
OutPort_5384751_0 | SOURCE | 3601.001.01 Inntak: 1
InPort_5378358_3 | SINK | 3601.001.05 Avtrekk: 7
OutPort_5381246_0 | SOURCE | 3601.001.05 Avtrekk: 7
InPort_5384720_0 | SINK | 3601.001.02 Avkast: 1
OutPort_5378358_4 | SOURCE | 3601.001.02 Avkast: 1
Port_5378894_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380187_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5378894_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5379271_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379287_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379271_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379287_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383327_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379287_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5438774_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379288_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5438890_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379288_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379355_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383326_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379355_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383477_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379419_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383477_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379419_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5428028_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5379725_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5434998_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5379725_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5379743_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5434971_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5379743_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5379933_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 17
Port_5379933_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 17
Port_5380115_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 17
Port_5380107_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 17
Port_5380115_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 17
Port_5380107_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 17
Port_5380177_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380187_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380177_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430533_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380260_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427087_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380260_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380260_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430533_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380260_3 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430576_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380260_4 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5431589_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380260_5 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5433732_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380260_6 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5434199_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380464_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5426892_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5380464_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427738_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5380545_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427082_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380545_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427028_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380578_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5404275_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380578_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427497_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5380729_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385079_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5380729_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385081_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381069_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381077_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381069_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381087_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381077_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385068_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381079_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5427819_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381079_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381087_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5427784_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381114_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381124_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381114_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381124_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383039_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381148_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 14
Port_5381148_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 14
OutPort_5381217_1 | SOURCE | 3601.001.04 Tilluft: 5
InPort_5381246_1 | SINK | 3601.001.05 Avtrekk: 7
Port_5381721_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385079_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381721_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381742_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381736_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381742_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381736_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381752_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381752_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5382006_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5381774_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5385123_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381774_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5385125_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381791_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5385123_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381791_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381806_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381800_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381806_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381800_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381855_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381855_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381944_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381944_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381984_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381952_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381984_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5381952_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5433552_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5382006_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5382023_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5382014_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5433487_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5382014_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5382023_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5433383_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5382469_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5383555_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5382469_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5428062_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5382603_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383046_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5382603_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383017_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383038_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383017_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383046_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383038_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383039_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383038_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5434971_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383039_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435484_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5383090_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5383101_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5383090_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5427985_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5383101_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5383135_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5383135_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5383135_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5439016_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5383316_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383326_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383316_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383326_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383327_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383477_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383504_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383504_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383508_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383508_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5383547_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5383555_3 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5383547_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5383555_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5434298_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5383579_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5434298_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5383579_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5383629_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 4
Port_5383629_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 4
Port_5383819_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383830_3 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383819_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383856_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383830_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383831_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383830_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5434998_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383831_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385067_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383848_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383856_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383848_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383913_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383913_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383915_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5383915_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5384228_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5384228_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432325_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5384228_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432223_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5384228_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432239_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5384228_4 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432258_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5384228_5 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432266_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
InPort_5431038_1 | SINK | 3601.001.04 Tilluft: 2
OutPort_5384511_0 | SOURCE | 3601.001.04 Tilluft: 2
Port_5384511_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427326_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5384511_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431210_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5384511_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5434049_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5384541_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5384560_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5384541_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5384541_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430696_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5384541_3 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430720_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5384541_4 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5431857_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5384550_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5384560_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5384550_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430576_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
OutPort_5384720_1 | SOURCE | 3601.001.02 Avkast: 1
InPort_5384751_1 | SINK | 3601.001.01 Inntak: 1
Port_5385065_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385067_3 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385065_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385081_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385067_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385068_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5385109_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435403_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5385109_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5385125_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5385150_0 | SOURCEANDSINK
Port_5385150_1 | SOURCEANDSINK
Port_5385228_0 | SOURCEANDSINK
Port_5385228_1 | SOURCEANDSINK
Port_5385927_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5386143_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5385927_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5434047_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5386135_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5386143_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5386135_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5386151_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5386145_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5386151_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5386145_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5386218_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5386237_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5386218_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5434197_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5386227_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5386237_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5386227_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5386245_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5386239_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5386245_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5386239_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5401633_0 | SOURCEANDSINK | 3601.001.01 Inntak: 6
Port_5401633_1 | SOURCEANDSINK | 3601.001.01 Inntak: 6
Port_5401705_0 | SOURCEANDSINK | 3601.001.02 Avkast: 3
Port_5401705_1 | SOURCEANDSINK | 3601.001.02 Avkast: 3
OutPort_5403368_1 | SOURCE
Port_5403904_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427024_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5403904_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5404271_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5404026_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5404148_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5404026_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427272_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5404141_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5426892_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5404141_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5404148_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5404268_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5404271_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5404268_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5404275_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
InPort_5404380_0 | SINK | 3601.001.01 Inntak: 5
OutPort_5404294_1 | SOURCE | 3601.001.01 Inntak: 5
OutPort_5404380_1 | SOURCE | 3601.001.01 Inntak: 5
Port_5404444_0 | SOURCEANDSINK | 3601.001.02 Avkast: 4
Port_5404444_1 | SOURCEANDSINK | 3601.001.02 Avkast: 4
InPort_5424750_0 | SINK | 3601.001.04 Tilluft: 13
OutPort_5424478_1 | SOURCE | 3601.001.04 Tilluft: 13
InPort_5424478_2 | SINK | 3601.001.01 Inntak: 3
OutPort_5424660_0 | SOURCE | 3601.001.01 Inntak: 3
InPort_5424478_3 | SINK | 3601.001.05 Avtrekk: 13
OutPort_5424720_0 | SOURCE | 3601.001.05 Avtrekk: 13
InPort_5424690_0 | SINK | 3601.001.02 Avkast: 5
OutPort_5424478_4 | SOURCE | 3601.001.02 Avkast: 5
InPort_5424660_1 | SINK | 3601.001.01 Inntak: 3
OutPort_5424690_1 | SOURCE | 3601.001.02 Avkast: 5
InPort_5424720_1 | SINK | 3601.001.05 Avtrekk: 13
OutPort_5424750_1 | SOURCE | 3601.001.04 Tilluft: 13
Port_5424839_0 | SOURCEANDSINK
Port_5424839_1 | SOURCEANDSINK
Port_5424894_0 | SOURCEANDSINK
Port_5424894_1 | SOURCEANDSINK
Port_5424974_0 | SOURCEANDSINK
Port_5424974_1 | SOURCEANDSINK
Port_5425042_0 | SOURCEANDSINK
Port_5425042_1 | SOURCEANDSINK
Port_5425108_0 | SOURCEANDSINK
Port_5425108_1 | SOURCEANDSINK
Port_5425328_0 | SOURCEANDSINK
Port_5425328_1 | SOURCEANDSINK
Port_5425662_0 | SOURCEANDSINK
Port_5425662_1 | SOURCEANDSINK
Port_5425748_0 | SOURCEANDSINK
Port_5425748_1 | SOURCEANDSINK
Port_5426050_0 | SOURCEANDSINK
Port_5426050_1 | SOURCEANDSINK
Port_5426121_0 | SOURCEANDSINK
Port_5426121_1 | SOURCEANDSINK
Port_5426258_0 | SOURCEANDSINK
Port_5426258_1 | SOURCEANDSINK
Port_5426383_0 | SOURCEANDSINK
Port_5426383_1 | SOURCEANDSINK
Port_5427021_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427024_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427021_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427028_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427079_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427082_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427079_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427087_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427132_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427268_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427132_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427322_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427265_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427268_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427265_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427272_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427319_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427322_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427319_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427326_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427491_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427497_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427491_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5427606_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427742_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427606_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427735_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427738_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427735_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427742_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5427784_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5427819_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5427980_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5427985_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5427980_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5427999_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5427989_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5427999_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5427989_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5428025_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5428028_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5428025_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5428120_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5428059_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5428062_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5428059_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5428162_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5428112_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5428120_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5428112_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5428154_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5428162_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5428154_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 4
Port_5429657_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5433739_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5429657_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5433741_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5429664_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5433739_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5429664_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5429795_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429795_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429815_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429815_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429869_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429824_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429834_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429824_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429834_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430228_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429834_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429835_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429835_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429868_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429858_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429868_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429858_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429882_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429868_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429909_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429869_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429909_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429874_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429882_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429874_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5429935_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5429935_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5429988_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5429988_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430063_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430022_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430068_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430022_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430062_3 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430029_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430068_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430029_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430062_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430082_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430062_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430132_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430063_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430082_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430117_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430131_3 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430117_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430131_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430177_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430131_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430132_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430165_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430176_3 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430165_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430176_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430396_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430176_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430663_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430177_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430396_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430217_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430227_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430217_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430227_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430889_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430227_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431281_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430228_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430889_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430356_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431543_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430356_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431359_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5430663_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 17
Port_5430685_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430696_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430685_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430712_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430720_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5430712_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5431182_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431210_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431182_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431361_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431281_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431543_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431281_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5437823_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431281_3 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5437839_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431356_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431359_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431356_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431361_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5431429_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5431589_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5431429_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5431743_0 | SOURCEANDSINK | 3101.001.01 Spillvann 2
Port_5431743_1 | SOURCEANDSINK | 3101.001.01 Spillvann 2
Port_5431849_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5431857_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5431849_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5432212_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432223_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432212_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432233_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432239_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432233_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432252_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432258_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432252_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432260_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432266_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432260_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432315_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432325_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5432315_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 3
Port_5433383_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5433487_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 6
Port_5433542_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5433552_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5433542_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5433728_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5433732_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5433728_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5433741_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5434044_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5434049_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5434044_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5434047_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5434194_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5434199_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5434194_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5434197_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 1
Port_5435393_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435403_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435393_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435479_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435476_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435484_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435476_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435479_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 6
Port_5435501_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435520_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435501_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435593_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435510_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435520_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435510_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435572_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435593_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435572_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435639_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435596_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435639_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435596_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 12
Port_5435656_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435660_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435656_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435664_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435658_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435660_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435658_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435662_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435664_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435662_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435668_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435666_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435668_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435666_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 2
Port_5435719_0 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5435719_1 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437726_1 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5435728_0 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437569_1 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5435728_1 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5435822_0 | SOURCEANDSINK | 3601.001.02 Avkast: 8
Port_5435822_1 | SOURCEANDSINK | 3601.001.02 Avkast: 8
Port_5435826_1 | SOURCEANDSINK | 3601.001.02 Avkast: 8
Port_5435824_0 | SOURCEANDSINK | 3601.001.02 Avkast: 8
Port_5435826_2 | SOURCEANDSINK | 3601.001.02 Avkast: 8
Port_5435824_1 | SOURCEANDSINK | 3601.001.02 Avkast: 8
OutPort_5437383_1 | SOURCE
OutPort_5437436_1 | SOURCE
Port_5437515_0 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437723_1 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437515_1 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437726_2 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437562_0 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437723_2 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437562_1 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437569_2 | SOURCEANDSINK | 3601.001.01 Inntak: 7
Port_5437814_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5437823_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5437814_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5437833_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5437839_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5437833_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 2
Port_5437869_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 8
Port_5437869_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 8
Port_5438592_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 8
Port_5438189_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438189_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438246_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438238_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438246_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438238_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438568_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438266_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438444_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438266_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438545_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438441_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438444_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438441_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438537_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438545_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438537_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 5
Port_5438560_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438568_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438560_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 7
Port_5438584_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 8
Port_5438592_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 8
Port_5438584_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 8
Port_5438608_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 8
Port_5438608_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 8
Port_5438626_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 8
Port_5438618_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 8
Port_5438626_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 8
Port_5438618_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 8
Port_5438687_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5439011_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5438687_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5438774_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5438885_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5438882_0 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5438885_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5438882_1 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5438890_2 | SOURCEANDSINK | 3601.001.04 Tilluft: 1
Port_5439008_0 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5439016_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5439008_1 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3
Port_5439011_2 | SOURCEANDSINK | 3601.001.05 Avtrekk: 3

# IfcFlowFitting: Lindab ESU:ESU, Lindab ESU:ESU:5431038
In: 2. etasje
Type - Material: DF_Material1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Pset_DistributionFlowElementCommon - Reference: ESU; sets with these values: 2
Group: 3601.001.04 Tilluft: 2

# IfcFlowFitting: Lindab TCPU:TCPU (13)
In: 1. etasje
Type - Material: DF_Material1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Pset_DistributionFlowElementCommon - Reference: TCPU; sets with these values: 2
Name (Lindab TCPU:TCPU:...) | Group
5379287 | 3601.001.04 Tilluft: 1
5383038 | 3601.001.04 Tilluft: 6
5383326 | 3601.001.04 Tilluft: 1
5383477 | 3601.001.04 Tilluft: 1
5383555 | 3601.001.05 Avtrekk: 4
5383830 | 3601.001.05 Avtrekk: 6
5385067 | 3601.001.05 Avtrekk: 6
5429834 | 3601.001.04 Tilluft: 2
5429868 | 3601.001.04 Tilluft: 2
5430062 | 3601.001.05 Avtrekk: 17
5430131 | 3601.001.05 Avtrekk: 17
5430176 | 3601.001.05 Avtrekk: 17
5430227 | 3601.001.04 Tilluft: 2

# IfcFlowFitting: magicirc_elbow_full_radius_NOR:magicirc_elbow_full_radius_NOR (32)
Type - Material: 3601.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_NOR; sets with these values: 2
Name (magicirc_elbow_full_radius_NOR:magicirc_elbow_full_radius_NOR:...) | In | Group
5381077 | 1. etasje | 3601.001.05 Avtrekk: 6
5381087 | 2. etasje | 3601.001.05 Avtrekk: 6
5381124 | 1. etasje | 3601.001.04 Tilluft: 6
5381742 | 1. etasje | 3601.001.05 Avtrekk: 6
5381752 | 1. etasje | 3601.001.05 Avtrekk: 6
5381806 | 1. etasje | 3601.001.04 Tilluft: 6
5381855 | 1. etasje | 3601.001.04 Tilluft: 6
5383101 | 1. etasje | 3601.001.05 Avtrekk: 3
5384560 | 1. etasje | 3601.001.05 Avtrekk: 1
5385079 | 1. etasje | 3601.001.05 Avtrekk: 6
5385081 | 1. etasje | 3601.001.05 Avtrekk: 6
5385123 | 1. etasje | 3601.001.04 Tilluft: 6
5385125 | 1. etasje | 3601.001.04 Tilluft: 6
5427024 | 2. etasje | 3601.001.05 Avtrekk: 1
5427082 | 2. etasje | 3601.001.05 Avtrekk: 1
5427087 | 2. etasje | 3601.001.05 Avtrekk: 1
5427268 | 2. etasje | 3601.001.04 Tilluft: 2
5427322 | 2. etasje | 3601.001.04 Tilluft: 2
5427497 | 2. etasje | 3601.001.05 Avtrekk: 1
5427738 | 2. etasje | 3601.001.04 Tilluft: 2
5427742 | 2. etasje | 3601.001.04 Tilluft: 2
5427985 | 1. etasje | 3601.001.05 Avtrekk: 3
5427999 | 1. etasje | 3601.001.05 Avtrekk: 3
5428062 | 1. etasje | 3601.001.05 Avtrekk: 4
5428162 | 1. etasje | 3601.001.05 Avtrekk: 4
5432325 | 1. etasje | 3601.001.04 Tilluft: 3
5433739 | 1. etasje | 3601.001.05 Avtrekk: 1
5433741 | 1. etasje | 3601.001.05 Avtrekk: 1
5435403 | 1. etasje | 3601.001.04 Tilluft: 6
5435520 | 01 | 3601.001.04 Tilluft: 12
5435660 | 01 | 3601.001.05 Avtrekk: 2
5439011 | 1. etasje | 3601.001.05 Avtrekk: 3

# IfcFlowFitting: magicirc_elbow_full_radius_NOR:magicirc_elbow_full_radius_NOR (39)
Type - Material: 3601.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_NOR; sets with these values: 2
Name (magicirc_elbow_full_radius_NOR:magicirc_elbow_full_radius_NOR:...) | In | Group
5380115 | 2. etasje | 3601.001.04 Tilluft: 17
5380187 | 2. etasje | 3601.001.05 Avtrekk: 1
5383046 | 1. etasje | 3601.001.04 Tilluft: 6
5383856 | 1. etasje | 3601.001.05 Avtrekk: 6
5383913 | 1. etasje | 3601.001.05 Avtrekk: 6
5386143 | 1. etasje | 3601.001.04 Tilluft: 2
5386151 | 1. etasje | 3601.001.04 Tilluft: 2
5386237 | 1. etasje | 3601.001.05 Avtrekk: 1
5386245 | 1. etasje | 3601.001.05 Avtrekk: 1
5404148 | 2. etasje | 3601.001.04 Tilluft: 2
5404271 | 2. etasje | 3601.001.05 Avtrekk: 1
5404275 | 2. etasje | 3601.001.05 Avtrekk: 1
5426892 | 2. etasje | 3601.001.04 Tilluft: 2
5427028 | 2. etasje | 3601.001.05 Avtrekk: 1
5427272 | 2. etasje | 3601.001.04 Tilluft: 2
5427326 | 2. etasje | 3601.001.04 Tilluft: 2
5428028 | 1. etasje | 3601.001.04 Tilluft: 1
5428120 | 1. etasje | 3601.001.04 Tilluft: 1
5429815 | 1. etasje | 3601.001.04 Tilluft: 2
5429882 | 1. etasje | 3601.001.04 Tilluft: 2
5429988 | 1. etasje | 3601.001.05 Avtrekk: 17
5430068 | 1. etasje | 3601.001.05 Avtrekk: 17
5431359 | 1. etasje | 3601.001.04 Tilluft: 2
5431361 | 2. etasje | 3601.001.04 Tilluft: 2
5434047 | 1. etasje | 3601.001.04 Tilluft: 2
5434197 | 1. etasje | 3601.001.05 Avtrekk: 1
5435479 | 1. etasje | 3601.001.04 Tilluft: 6
5435826 | 01 | 3601.001.02 Avkast: 8
5437569 | 1. etasje | 3601.001.01 Inntak: 7
5437723 | 1. etasje | 3601.001.01 Inntak: 7
5437726 | 01 | 3601.001.01 Inntak: 7
5438246 | 1. etasje | 3601.001.04 Tilluft: 7
5438444 | 1. etasje | 3601.001.05 Avtrekk: 5
5438545 | 1. etasje | 3601.001.05 Avtrekk: 5
5438568 | 1. etasje | 3601.001.04 Tilluft: 7
5438592 | 1. etasje | 3601.001.05 Avtrekk: 8
5438626 | 2. etasje | 3601.001.04 Tilluft: 8
5438885 | 1. etasje | 3601.001.04 Tilluft: 1
5438890 | 1. etasje | 3601.001.04 Tilluft: 1

# IfcFlowFitting: magicirc_reduction_NOR:magicirc_reduction_NOR (18)
Type - Material: Material_Duct
Pset_DistributionFlowElementCommon - Reference: magicirc_reduction_NOR; sets with these values: 2
Name (magicirc_reduction_NOR:magicirc_reduction_NOR:...) | In | Group
5381984 | 1. etasje | 3601.001.04 Tilluft: 6
5382023 | 1. etasje | 3601.001.05 Avtrekk: 6
5383504 | 1. etasje | 3601.001.04 Tilluft: 1
5427819 | 2. etasje | 3601.001.05 Avtrekk: 6
5429909 | 1. etasje | 3601.001.04 Tilluft: 2
5430082 | 1. etasje | 3601.001.05 Avtrekk: 17
5430396 | 1. etasje | 3601.001.05 Avtrekk: 17
5430889 | 1. etasje | 3601.001.04 Tilluft: 2
5431543 | 1. etasje | 3601.001.04 Tilluft: 2
5433487 | 1. etasje | 3601.001.05 Avtrekk: 6
5433552 | 1. etasje | 3601.001.04 Tilluft: 6
5434298 | 1. etasje | 3601.001.05 Avtrekk: 4
5434971 | 1. etasje | 3601.001.04 Tilluft: 6
5434998 | 1. etasje | 3601.001.05 Avtrekk: 6
5435593 | 01 | 3601.001.04 Tilluft: 12
5435639 | 1. etasje | 3601.001.04 Tilluft: 12
5435664 | 01 | 3601.001.05 Avtrekk: 2
5435668 | 1. etasje | 3601.001.05 Avtrekk: 2

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (10)
Type - Material: 3601.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...) | In | Group
5430533 | 2. etasje | 3601.001.05 Avtrekk: 1
5430576 | 1. etasje | 3601.001.05 Avtrekk: 1
5430696 | 1. etasje | 3601.001.05 Avtrekk: 1
5430720 | 1. etasje | 3601.001.05 Avtrekk: 1
5431589 | 2. etasje | 3601.001.05 Avtrekk: 1
5431857 | 1. etasje | 3601.001.05 Avtrekk: 1
5433732 | 1. etasje | 3601.001.05 Avtrekk: 1
5434199 | 1. etasje | 3601.001.05 Avtrekk: 1
5435484 | 1. etasje | 3601.001.04 Tilluft: 6
5439016 | 1. etasje | 3601.001.05 Avtrekk: 3

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (8)
Type - Material: 3601.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...) | In | Group
5431210 | 2. etasje | 3601.001.04 Tilluft: 2
5432223 | 1. etasje | 3601.001.04 Tilluft: 3
5432239 | 1. etasje | 3601.001.04 Tilluft: 3
5432258 | 1. etasje | 3601.001.04 Tilluft: 3
5432266 | 1. etasje | 3601.001.04 Tilluft: 3
5434049 | 1. etasje | 3601.001.04 Tilluft: 2
5437823 | 1. etasje | 3601.001.04 Tilluft: 2
5437839 | 1. etasje | 3601.001.04 Tilluft: 2

# IfcFlowSegment: Cable Tray with Fittings:Ladder Cable Tray (14)
Type - PredefinedType: CABLETRAYSEGMENT
Pset_DistributionFlowElementCommon - Reference: Ladder Cable Tray; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray with Fittings:Ladder Cable Tray:...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm)
5385150 | 1. etasje | 10480
5385228 | 1. etasje | 1340
5424839 | 1. etasje | 2760
5424894 | 1. etasje | 10600
5424974 | 1. etasje | 7160
5425042 | 1. etasje | 1560
5425108 | 1. etasje | 2100
5425328 | 1. etasje | 1760
5425662 | 1. etasje | 3360.18
5425748 | 1. etasje | 600
5426050 | 1. etasje | 1640
5426121 | 1. etasje | 580
5426258 | 2. etasje | 2798.62
5426383 | 1. etasje | 1380

# IfcFlowSegment: Pipe Types:MA, Pipe Types:MA:5431743
In: 01
Type - Material: 3101.001 SPV
Type - Pset_ManufacturerTypeInformation - Manufacturer: Standard
Pset_DistributionFlowElementCommon - Reference: MA; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND; Length: 1040 mm
Pset_FlowSegmentDuctSegment - Length: 1040 mm
Pset_FlowSegmentPipeSegment - Length: 1040 mm; InvertElevation: 6392.76 mm
Group: 3101.001.01 Spillvann 2

# IfcFlowSegment: Rectangular Duct:Rektangulær kanal (8)
In: 2. etasje
Type - Material: 3601.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: Rektangulær kanal; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Rectangular Duct:Rektangulær kanal:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
5381217 | 1020 | 3601.001.04 Tilluft: 5
5381246 | 1260 | 3601.001.05 Avtrekk: 7
5384720 | 1240 | 3601.001.02 Avkast: 1
5384751 | 2020 | 3601.001.01 Inntak: 1
5424660 | 1100 | 3601.001.01 Inntak: 3
5424690 | 335.593 | 3601.001.02 Avkast: 5
5424720 | 235.593 | 3601.001.05 Avtrekk: 13
5424750 | 335.593 | 3601.001.04 Tilluft: 13

# IfcFlowSegment: Round Duct:Sirkulær kanal (149)
Type - Material: 3601.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal:...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
5378894 | 2. etasje | 9338.72 | 3601.001.05 Avtrekk: 1
5379271 | 1. etasje | 400 | 3601.001.04 Tilluft: 1
5379288 | 1. etasje | 682.974 | 3601.001.04 Tilluft: 1
5379355 | 1. etasje | 1446.57 | 3601.001.04 Tilluft: 1
5379419 | 1. etasje | 385 | 3601.001.04 Tilluft: 1
5379725 | 1. etasje | 9100 | 3601.001.05 Avtrekk: 6
5379743 | 1. etasje | 6320 | 3601.001.04 Tilluft: 6
5379933 | 2. etasje | 9455 | 3601.001.04 Tilluft: 17
5380107 | 2. etasje | 1206.45 | 3601.001.04 Tilluft: 17
5380177 | 2. etasje | 1247.48 | 3601.001.05 Avtrekk: 1
5380260 | 2. etasje | 4400 | 3601.001.05 Avtrekk: 1
5380464 | 2. etasje | 5466.03 | 3601.001.04 Tilluft: 2
5380545 | 2. etasje | 1806.85 | 3601.001.05 Avtrekk: 1
5380578 | 2. etasje | 5066.03 | 3601.001.05 Avtrekk: 1
5380729 | 1. etasje | 3428.32 | 3601.001.05 Avtrekk: 6
5381069 | 2. etasje | 780 | 3601.001.05 Avtrekk: 6
5381079 | 2. etasje | 1235.46 | 3601.001.05 Avtrekk: 6
5381114 | 2. etasje | 638.143 | 3601.001.04 Tilluft: 6
5381148 | 2. etasje | 816.257 | 3601.001.04 Tilluft: 14
5381721 | 1. etasje | 1001.42 | 3601.001.05 Avtrekk: 6
5381736 | 1. etasje | 611.058 | 3601.001.05 Avtrekk: 6
5381774 | 1. etasje | 3675.57 | 3601.001.04 Tilluft: 6
5381791 | 1. etasje | 1880 | 3601.001.04 Tilluft: 6
5381800 | 1. etasje | 680 | 3601.001.04 Tilluft: 6
5381944 | 1. etasje | 2183.47 | 3601.001.04 Tilluft: 6
5381952 | 1. etasje | 3700 | 3601.001.04 Tilluft: 6
5382006 | 1. etasje | 2550 | 3601.001.05 Avtrekk: 6
5382014 | 1. etasje | 1800 | 3601.001.05 Avtrekk: 6
5382469 | 1. etasje | 351.816 | 3601.001.05 Avtrekk: 4
5382603 | 1. etasje | 2985 | 3601.001.04 Tilluft: 6
5383017 | 1. etasje | 18.7377 | 3601.001.04 Tilluft: 6
5383039 | 1. etasje | 5405.2 | 3601.001.04 Tilluft: 6
5383090 | 1. etasje | 180 | 3601.001.05 Avtrekk: 3
5383135 | 1. etasje | 5100 | 3601.001.05 Avtrekk: 3
5383316 | 1. etasje | 1485 | 3601.001.04 Tilluft: 1
5383327 | 1. etasje | 2228.45 | 3601.001.04 Tilluft: 1
5383508 | 1. etasje | 1049.5 | 3601.001.04 Tilluft: 1
5383547 | 1. etasje | 2060 | 3601.001.05 Avtrekk: 4
5383579 | 1. etasje | 1200 | 3601.001.05 Avtrekk: 4
5383629 | 1. etasje | 3000 | 3601.001.04 Tilluft: 4
5383819 | 1. etasje | 18.7377 | 3601.001.05 Avtrekk: 6
5383831 | 1. etasje | 1071.47 | 3601.001.05 Avtrekk: 6
5383848 | 1. etasje | 950 | 3601.001.05 Avtrekk: 6
5383915 | 1. etasje | 285 | 3601.001.05 Avtrekk: 6
5384228 | 1. etasje | 10490 | 3601.001.04 Tilluft: 3
5384511 | 2. etasje | 4974.57 | 3601.001.04 Tilluft: 2
5384541 | 1. etasje | 4950 | 3601.001.05 Avtrekk: 1
5384550 | 1. etasje | 726.402 | 3601.001.05 Avtrekk: 1
5385065 | 1. etasje | 871.767 | 3601.001.05 Avtrekk: 6
5385068 | 1. etasje | 1204.14 | 3601.001.05 Avtrekk: 6
5385109 | 1. etasje | 472.101 | 3601.001.04 Tilluft: 6
5385927 | 1. etasje | 1210.77 | 3601.001.04 Tilluft: 2
5386135 | 1. etasje | 872.355 | 3601.001.04 Tilluft: 2
5386145 | 1. etasje | 2237.41 | 3601.001.04 Tilluft: 2
5386218 | 1. etasje | 2084.69 | 3601.001.05 Avtrekk: 1
5386227 | 1. etasje | 310.977 | 3601.001.05 Avtrekk: 1
5386239 | 1. etasje | 1894.01 | 3601.001.05 Avtrekk: 1
5401633 | 2. etasje | 1360 | 3601.001.01 Inntak: 6
5401705 | 2. etasje | 1500 | 3601.001.02 Avkast: 3
5403904 | 2. etasje | 1838.9 | 3601.001.05 Avtrekk: 1
5404026 | 2. etasje | 807.971 | 3601.001.04 Tilluft: 2
5404141 | 2. etasje | 87.509 | 3601.001.04 Tilluft: 2
5404268 | 2. etasje | 52.0508 | 3601.001.05 Avtrekk: 1
5404380 | 2. etasje | 2640 | 3601.001.01 Inntak: 5
5404444 | 2. etasje | 1720 | 3601.001.02 Avkast: 4
5427021 | 2. etasje | 358.585 | 3601.001.05 Avtrekk: 1
5427079 | 2. etasje | 25.1837 | 3601.001.05 Avtrekk: 1
5427132 | 2. etasje | 2862.26 | 3601.001.04 Tilluft: 2
5427265 | 2. etasje | 414.089 | 3601.001.04 Tilluft: 2
5427319 | 2. etasje | 146.952 | 3601.001.04 Tilluft: 2
5427491 | 2. etasje | 500 | 3601.001.05 Avtrekk: 1
5427606 | 2. etasje | 480 | 3601.001.04 Tilluft: 2
5427735 | 2. etasje | 220 | 3601.001.04 Tilluft: 2
5427784 | 2. etasje | 369.536 | 3601.001.05 Avtrekk: 6
5427980 | 1. etasje | 1016.77 | 3601.001.05 Avtrekk: 3
5427989 | 1. etasje | 1540 | 3601.001.05 Avtrekk: 3
5428025 | 1. etasje | 773.162 | 3601.001.04 Tilluft: 1
5428059 | 1. etasje | 1003.16 | 3601.001.05 Avtrekk: 4
5428112 | 1. etasje | 1185 | 3601.001.04 Tilluft: 1
5428154 | 1. etasje | 520 | 3601.001.05 Avtrekk: 4
5429657 | 1. etasje | 1104.73 | 3601.001.05 Avtrekk: 1
5429664 | 1. etasje | 1190 | 3601.001.05 Avtrekk: 1
5429795 | 1. etasje | 1160.52 | 3601.001.04 Tilluft: 2
5429824 | 1. etasje | 960.522 | 3601.001.04 Tilluft: 2
5429835 | 1. etasje | 1824.38 | 3601.001.04 Tilluft: 2
5429858 | 1. etasje | 3327.35 | 3601.001.04 Tilluft: 2
5429869 | 1. etasje | 533.115 | 3601.001.04 Tilluft: 2
5429874 | 1. etasje | 2360 | 3601.001.04 Tilluft: 2
5429935 | 1. etasje | 1107.75 | 3601.001.05 Avtrekk: 17
5430022 | 1. etasje | 3527.25 | 3601.001.05 Avtrekk: 17
5430029 | 1. etasje | 1240 | 3601.001.05 Avtrekk: 17
5430063 | 1. etasje | 142.385 | 3601.001.05 Avtrekk: 17
5430117 | 1. etasje | 760.474 | 3601.001.05 Avtrekk: 17
5430132 | 1. etasje | 629.032 | 3601.001.05 Avtrekk: 17
5430165 | 1. etasje | 1667.25 | 3601.001.05 Avtrekk: 17
5430177 | 1. etasje | 1543.46 | 3601.001.05 Avtrekk: 17
5430217 | 1. etasje | 1494.48 | 3601.001.04 Tilluft: 2
5430228 | 1. etasje | 1691.03 | 3601.001.04 Tilluft: 2
5430356 | 1. etasje | 858.262 | 3601.001.04 Tilluft: 2
5430663 | 1. etasje | 10740 | 3601.001.05 Avtrekk: 17
5430685 | 1. etasje | 475 | 3601.001.05 Avtrekk: 1
5430712 | 1. etasje | 535 | 3601.001.05 Avtrekk: 1
5431182 | 2. etasje | 695.804 | 3601.001.04 Tilluft: 2
5431281 | 1. etasje | 9179.9 | 3601.001.04 Tilluft: 2
5431356 | 1. etasje | 330.123 | 3601.001.04 Tilluft: 2
5431429 | 2. etasje | 640 | 3601.001.05 Avtrekk: 1
5431849 | 1. etasje | 475 | 3601.001.05 Avtrekk: 1
5432212 | 1. etasje | 215 | 3601.001.04 Tilluft: 3
5432233 | 1. etasje | 215 | 3601.001.04 Tilluft: 3
5432252 | 1. etasje | 215 | 3601.001.04 Tilluft: 3
5432260 | 1. etasje | 215 | 3601.001.04 Tilluft: 3
5432315 | 1. etasje | 770 | 3601.001.04 Tilluft: 3
5433383 | 1. etasje | 3306.82 | 3601.001.05 Avtrekk: 6
5433542 | 1. etasje | 1380 | 3601.001.04 Tilluft: 6
5433728 | 1. etasje | 801.302 | 3601.001.05 Avtrekk: 1
5434044 | 1. etasje | 873.497 | 3601.001.04 Tilluft: 2
5434194 | 1. etasje | 891.302 | 3601.001.05 Avtrekk: 1
5435393 | 1. etasje | 19.6644 | 3601.001.04 Tilluft: 6
5435476 | 1. etasje | 76.0235 | 3601.001.04 Tilluft: 6
5435501 | 01 | 2520 | 3601.001.04 Tilluft: 12
5435510 | 01 | 820 | 3601.001.04 Tilluft: 12
5435572 | 1. etasje | 2400 | 3601.001.04 Tilluft: 12
5435596 | 1. etasje | 1842.5 | 3601.001.04 Tilluft: 12
5435656 | 01 | 3146.17 | 3601.001.05 Avtrekk: 2
5435658 | 01 | 820 | 3601.001.05 Avtrekk: 2
5435662 | 1. etasje | 2400 | 3601.001.05 Avtrekk: 2
5435666 | 1. etasje | 1842.5 | 3601.001.05 Avtrekk: 2
5435719 | 01 | 20 | 3601.001.01 Inntak: 7
5435728 | 1. etasje | 1357.38 | 3601.001.01 Inntak: 7
5435822 | 01 | 20 | 3601.001.02 Avkast: 8
5435824 | 01 | 7562.02 | 3601.001.02 Avkast: 8
5437515 | 1. etasje | 6319.15 | 3601.001.01 Inntak: 7
5437562 | 1. etasje | 856.604 | 3601.001.01 Inntak: 7
5437814 | 1. etasje | 555 | 3601.001.04 Tilluft: 2
5437833 | 1. etasje | 555 | 3601.001.04 Tilluft: 2
5437869 | 1. etasje | 3000 | 3601.001.05 Avtrekk: 8
5438189 | 1. etasje | 240 | 3601.001.04 Tilluft: 7
5438238 | 1. etasje | 2480 | 3601.001.04 Tilluft: 7
5438266 | 1. etasje | 738.028 | 3601.001.05 Avtrekk: 5
5438441 | 1. etasje | 391.085 | 3601.001.05 Avtrekk: 5
5438537 | 2. etasje | 740 | 3601.001.05 Avtrekk: 5
5438560 | 2. etasje | 1370.34 | 3601.001.04 Tilluft: 7
5438584 | 2. etasje | 1377.14 | 3601.001.05 Avtrekk: 8
5438608 | 2. etasje | 3563.37 | 3601.001.04 Tilluft: 8
5438618 | 2. etasje | 2100 | 3601.001.04 Tilluft: 8
5438687 | 1. etasje | 606.4 | 3601.001.05 Avtrekk: 3
5438774 | 1. etasje | 433.91 | 3601.001.04 Tilluft: 1
5438882 | 1. etasje | 42.025 | 3601.001.04 Tilluft: 1
5439008 | 1. etasje | 136.845 | 3601.001.05 Avtrekk: 3

# IfcFlowTerminal: KAI:KAI-2-400, KAI:KAI-2-400:5403368
In: 2. etasje
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: TROX
Pset_DistributionFlowElementCommon - Reference: KAI-2-400; sets with these values: 2

# IfcFlowTerminal: KAI:KAI-2B-630, KAI:KAI-2B-630:5404294
In: 2. etasje
Type - Material: 3601.001 Inntak
Type - Pset_ManufacturerTypeInformation - Manufacturer: TROX
Pset_DistributionFlowElementCommon - Reference: KAI-2B-630; sets with these values: 2
Group: 3601.001.01 Inntak: 5

# IfcFlowTerminal: Wall cowl V13 black-0001:160-112745 (2)
In: 1. etasje
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Flexit
Pset_DistributionFlowElementCommon - Reference: 160-112745; sets with these values: 2
Name (Wall cowl V13 black-0001:160-112745:...)
5437383
5437436
